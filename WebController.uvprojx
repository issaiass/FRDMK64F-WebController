# Keil uVision project WebController.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.10.0.4
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WebController
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:LED 1.2, Device:KSDK Configuration:FRDM-K64F 1.1.0, Device:KSDK Driver:GPIO 1.1.0, Device:KSDK Driver:RTC 1.1.0, Device:KSDK HAL:GPIO 1.1.0, Device:KSDK HAL:LPTMR 1.1.0, Device:KSDK HAL:MCG 1.1.0, Device:KSDK HAL:OSC 1.1.0, Device:KSDK HAL:PORT 1.1.0, Device:KSDK HAL:RTC 1.1.0, Device:KSDK HAL:SIM 1.1.0, Device:KSDK HAL:UART 1.1.0, Device:KSDK OSA:OSA 1.1.0, Device:KSDK System:Clock 1.1.0, Device:KSDK System:Interrupt 1.1.0, Device:KSDK Utility:Debug Console 1.1.0, Device:Startup 2.7
